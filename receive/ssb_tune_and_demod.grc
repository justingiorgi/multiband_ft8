options:
  parameters:
    author: Justin Giorgi AI6YM
    copyright: '2024'
    generate_options: hb
    id: ssb_tune_demod
    output_language: python
    title: SSB Tune & Demod
  states: {}

blocks:
- name: ssb_samp_rate
  id: variable
  parameters:
    value: '8000'
  states: {}
- name: audio_bw
  id: parameter
  parameters:
    label: Audio Bandwidth
    type: eng_float
    value: '3000'
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: tuning_freq - input_center_freq + (audio_bw / 2 * usb_lsb)
    decim: int(input_samp_rate / ssb_samp_rate)
    samp_rate: input_samp_rate
    taps: firdes.complex_band_pass(1, input_samp_rate, -(audio_bw/2), audio_bw/2, audio_bw/100)
    type: ccc
  states: {}
- name: input_center_freq
  id: parameter
  parameters:
    label: Input Center Freq
    type: intx
    value: '30000000'
  states: {}
- name: input_samp_rate
  id: parameter
  parameters:
    label: Input Sample Rate
    type: intx
    value: '400000'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: float
  states: {}
- name: pad_sink_1
  id: pad_sink
  parameters:
    label: tuned
    optional: 'True'
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: ssb_demodulator_0
  id: ssb_demodulator
  parameters:
    audio_bw: audio_bw
    usb_lsb: usb_lsb
  states: {}
- name: tuning_freq
  id: parameter
  parameters:
    label: Tuning Freq
    type: intx
    value: '28074000'
  states: {}
- name: usb_lsb
  id: parameter
  parameters:
    label: USB / LSB (1 / -1)
    type: intx
    value: '1'
  states: {}

connections:
- [freq_xlating_fir_filter_xxx_0, '0', pad_sink_1, '0']
- [freq_xlating_fir_filter_xxx_0, '0', ssb_demodulator_0, '0']
- [pad_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [ssb_demodulator_0, '0', pad_sink_0, '0']

metadata:
  file_format: 1
