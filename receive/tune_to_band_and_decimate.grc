options:
  parameters:
    author: Justin Giorgi AI6YM
    copyright: '2024'
    generate_options: hb
    id: band_tune_decimate
    output_language: python
    title: Tune to Band & Decimate
  states: {}

blocks:
- name: output_samp_rate
  id: variable_config
  parameters:
    config_file: default
    option: key
    section: main
    type: int
    value: int(input_samp_rate / decimation)
    writeback: None
  states: {}
- name: decimation
  id: parameter
  parameters:
    label: Decimation
    type: intx
    value: '50'
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: output_center_freq - input_center_freq
    decim: decimation
    samp_rate: input_samp_rate
    taps: firdes.complex_band_pass(1, input_samp_rate, -(output_bw/2), (output_bw/2), transition_bw)
    type: ccc
  states: {}
- name: input_center_freq
  id: parameter
  parameters:
    label: Input Center Freq
    type: intx
    value: '20000000'
  states: {}
- name: input_samp_rate
  id: parameter
  parameters:
    label: Input Sample Rate
    type: intx
    value: '20000000'
  states: {}
- name: output_bw
  id: parameter
  parameters:
    label: Output Bandwidth
    type: intx
    value: '200000'
  states: {}
- name: output_center_freq
  id: parameter
  parameters:
    label: Output Center Freq
    type: intx
    value: '20000000'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: transition_bw
  id: parameter
  parameters:
    label: Transition Bandwidth
    type: eng_float
    value: '2000'
  states: {}

connections:
- [freq_xlating_fir_filter_xxx_0, '0', pad_sink_0, '0']
- [pad_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']

metadata:
  file_format: 1
