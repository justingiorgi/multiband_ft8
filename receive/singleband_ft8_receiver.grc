options:
  parameters:
    author: Justin Giorgi AI6YM
    copyright: '2024'
    generate_options: qt_gui
    id: singleband_ft8_receiver
    output_language: python
    title: Single-Band FT8 Receiver
  states: {}

blocks:
- name: amp_on
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: 0,0,1,1
    label: Pre-Amp
    'true': 'True'
    type: bool
    value: 'False'
  states: {}
- name: band_center_freq
  id: variable
  parameters:
    value: '14200000'
  states: {}
- name: band_samp_rate
  id: variable
  parameters:
    value: '400000'
  states: {}
- name: ft8_freq
  id: variable
  parameters:
    value: '14074000'
  states: {}
- name: if_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,3
    label: IF Gain
    start: '0'
    step: '1'
    stop: '40'
    value: '32'
  states: {}
- name: sdr_center_freq
  id: variable
  parameters:
    value: '16000000'
  states: {}
- name: sdr_samp_rate
  id: variable
  parameters:
    value: '8000000'
  states: {}
- name: vga_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,4,1,3
    label: VGA Gain
    start: '0'
    step: '1'
    stop: '62'
    value: '16'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,7,1,3
    label: Volume
    start: '0'
    step: '0.1'
    stop: '10'
    value: '3'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: pulse:vsink0
    samp_rate: '16000'
  states: {}
- name: band_tune_decimate_0
  id: band_tune_decimate
  parameters:
    decimation: '20'
    input_center_freq: sdr_center_freq
    input_samp_rate: sdr_samp_rate
    output_bw: band_samp_rate
    output_center_freq: band_center_freq
    transition_bw: band_samp_rate/8
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: '8000'
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    gui_hint: 4,0,1,10
    name: '"SSB"'
    type: float
    update_time: '0.1'
  states: {}
- name: qtgui_waterfall_sink_x_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: band_samp_rate
    fc: band_center_freq
    fftsize: '1024'
    gui_hint: 2,0,1,10
    name: '"Band"'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_2
  id: qtgui_waterfall_sink_x
  parameters:
    bw: sdr_samp_rate
    fc: sdr_center_freq
    fftsize: '8192'
    gui_hint: 1,0,1,10
    name: '"Input"'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_3
  id: qtgui_waterfall_sink_x
  parameters:
    bw: '8000'
    fc: ft8_freq+1500
    fftsize: '1024'
    gui_hint: 3,0,1,10
    name: '"SSB Tune"'
    type: complex
    update_time: '0.1'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '2'
    type: fff
  states: {}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    amp: amp_on
    bandwidth: '4000000'
    center_freq: sdr_center_freq
    gain: if_gain
    samp_rate: sdr_samp_rate
    type: fc32
    vga: vga_gain
  states: {}
- name: ssb_tune_demod_0
  id: ssb_tune_demod
  parameters:
    audio_bw: '3000'
    input_center_freq: '28200000'
    input_samp_rate: '400000'
    tuning_freq: ft8_freq
    usb_lsb: '1'
  states: {}

connections:
- [band_tune_decimate_0, '0', qtgui_waterfall_sink_x_1, '0']
- [band_tune_decimate_0, '0', ssb_tune_demod_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [soapy_hackrf_source_0, '0', band_tune_decimate_0, '0']
- [soapy_hackrf_source_0, '0', qtgui_waterfall_sink_x_2, '0']
- [ssb_tune_demod_0, '0', qtgui_waterfall_sink_x_0, '0']
- [ssb_tune_demod_0, '0', rational_resampler_xxx_0, '0']
- [ssb_tune_demod_0, '1', qtgui_waterfall_sink_x_3, '0']

metadata:
  file_format: 1
