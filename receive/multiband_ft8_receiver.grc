options:
  parameters:
    author: Justin Giorgi AI6YM
    copyright: '2024'
    generate_options: no_gui
    id: multiband_ft8_receiver
    output_language: python
    title: MultiBand FT8 Receiver
  states: {}

blocks:
- name: amp_on
  id: variable
  parameters:
    value: '0'
  states: {}
- name: band_10m_center
  id: variable
  parameters:
    value: '28200000'
  states: {}
- name: band_12m_center
  id: variable
  parameters:
    value: '24800000'
  states: {}
- name: band_15m_center
  id: variable
  parameters:
    value: '21200000'
  states: {}
- name: band_17m_center
  id: variable
  parameters:
    value: '18060000'
  states: {}
- name: band_20m_center
  id: variable
  parameters:
    value: '14200000'
  states: {}
- name: band_samp_rate
  id: variable
  parameters:
    value: '400000'
  states: {}
- name: ft8_10m
  id: variable
  parameters:
    value: '28074000'
  states: {}
- name: ft8_12m
  id: variable
  parameters:
    value: '24915000'
  states: {}
- name: ft8_15m
  id: variable
  parameters:
    value: '21074000'
  states: {}
- name: ft8_17m
  id: variable
  parameters:
    value: '18100000'
  states: {}
- name: ft8_20m
  id: variable
  parameters:
    value: '14074000'
  states: {}
- name: if_gain
  id: variable
  parameters:
    value: '40'
  states: {}
- name: sdr_center_freq
  id: variable
  parameters:
    value: '20000000'
  states: {}
- name: sdr_samp_rate
  id: variable
  parameters:
    value: '20000000'
  states: {}
- name: vga_gain
  id: variable
  parameters:
    value: '32'
  states: {}
- name: volume
  id: variable
  parameters:
    value: '7'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: pulse:vsink10mft8
    samp_rate: '48000'
  states: {}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    device_name: pulse:vsink12mft8
    samp_rate: '48000'
  states: {}
- name: audio_sink_0_1
  id: audio_sink
  parameters:
    device_name: pulse:vsink15mft8
    samp_rate: '48000'
  states: {}
- name: audio_sink_0_2
  id: audio_sink
  parameters:
    device_name: pulse:vsink17mft8
    samp_rate: '48000'
  states: {}
- name: audio_sink_0_3
  id: audio_sink
  parameters:
    device_name: pulse:vsink20mft8
    samp_rate: '48000'
  states: {}
- name: band_tune_decimate_0
  id: band_tune_decimate
  parameters:
    decimation: '50'
    input_center_freq: sdr_center_freq
    input_samp_rate: sdr_samp_rate
    output_bw: band_samp_rate
    output_center_freq: band_10m_center
    transition_bw: band_samp_rate/8
  states: {}
- name: band_tune_decimate_0_0
  id: band_tune_decimate
  parameters:
    decimation: '50'
    input_center_freq: sdr_center_freq
    input_samp_rate: sdr_samp_rate
    output_bw: band_samp_rate
    output_center_freq: band_12m_center
    transition_bw: band_samp_rate/8
  states: {}
- name: band_tune_decimate_0_0_0
  id: band_tune_decimate
  parameters:
    decimation: '50'
    input_center_freq: sdr_center_freq
    input_samp_rate: sdr_samp_rate
    output_bw: band_samp_rate
    output_center_freq: band_15m_center
    transition_bw: band_samp_rate/8
  states: {}
- name: band_tune_decimate_0_0_0_0
  id: band_tune_decimate
  parameters:
    decimation: '50'
    input_center_freq: sdr_center_freq
    input_samp_rate: sdr_samp_rate
    output_bw: band_samp_rate
    output_center_freq: band_17m_center
    transition_bw: band_samp_rate/8
  states: {}
- name: band_tune_decimate_0_0_0_0_0
  id: band_tune_decimate
  parameters:
    decimation: '50'
    input_center_freq: sdr_center_freq
    input_samp_rate: sdr_samp_rate
    output_bw: band_samp_rate
    output_center_freq: band_20m_center
    transition_bw: band_samp_rate/8
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_2
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_3
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '6'
    type: fff
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '6'
    type: fff
  states: {}
- name: rational_resampler_xxx_0_1
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '6'
    type: fff
  states: {}
- name: rational_resampler_xxx_0_2
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '6'
    type: fff
  states: {}
- name: rational_resampler_xxx_0_3
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '6'
    type: fff
  states: {}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    amp: amp_on
    bandwidth: '20000000'
    center_freq: sdr_center_freq
    gain: if_gain
    samp_rate: sdr_samp_rate
    type: fc32
    vga: vga_gain
  states: {}
- name: ssb_tune_demod_0
  id: ssb_tune_demod
  parameters:
    audio_bw: '3000'
    input_center_freq: band_10m_center
    input_samp_rate: band_samp_rate
    tuning_freq: ft8_10m
    usb_lsb: '1'
  states: {}
- name: ssb_tune_demod_0_0
  id: ssb_tune_demod
  parameters:
    audio_bw: '3000'
    input_center_freq: band_12m_center
    input_samp_rate: band_samp_rate
    tuning_freq: ft8_12m
    usb_lsb: '1'
  states: {}
- name: ssb_tune_demod_0_0_0
  id: ssb_tune_demod
  parameters:
    audio_bw: '3000'
    input_center_freq: band_15m_center
    input_samp_rate: band_samp_rate
    tuning_freq: ft8_15m
    usb_lsb: '1'
  states: {}
- name: ssb_tune_demod_0_0_0_0
  id: ssb_tune_demod
  parameters:
    audio_bw: '3000'
    input_center_freq: band_17m_center
    input_samp_rate: band_samp_rate
    tuning_freq: ft8_17m
    usb_lsb: '1'
  states: {}
- name: ssb_tune_demod_0_0_0_0_0
  id: ssb_tune_demod
  parameters:
    audio_bw: '3000'
    input_center_freq: band_20m_center
    input_samp_rate: band_samp_rate
    tuning_freq: ft8_20m
    usb_lsb: '1'
  states: {}

connections:
- [band_tune_decimate_0, '0', ssb_tune_demod_0, '0']
- [band_tune_decimate_0_0, '0', ssb_tune_demod_0_0, '0']
- [band_tune_decimate_0_0_0, '0', ssb_tune_demod_0_0_0, '0']
- [band_tune_decimate_0_0_0_0, '0', ssb_tune_demod_0_0_0_0, '0']
- [band_tune_decimate_0_0_0_0_0, '0', ssb_tune_demod_0_0_0_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', audio_sink_0_0, '0']
- [blocks_multiply_const_vxx_0_1, '0', audio_sink_0_1, '0']
- [blocks_multiply_const_vxx_0_2, '0', audio_sink_0_2, '0']
- [blocks_multiply_const_vxx_0_3, '0', audio_sink_0_3, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [rational_resampler_xxx_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [rational_resampler_xxx_0_1, '0', blocks_multiply_const_vxx_0_1, '0']
- [rational_resampler_xxx_0_2, '0', blocks_multiply_const_vxx_0_2, '0']
- [rational_resampler_xxx_0_3, '0', blocks_multiply_const_vxx_0_3, '0']
- [soapy_hackrf_source_0, '0', band_tune_decimate_0, '0']
- [soapy_hackrf_source_0, '0', band_tune_decimate_0_0, '0']
- [soapy_hackrf_source_0, '0', band_tune_decimate_0_0_0, '0']
- [soapy_hackrf_source_0, '0', band_tune_decimate_0_0_0_0, '0']
- [soapy_hackrf_source_0, '0', band_tune_decimate_0_0_0_0_0, '0']
- [ssb_tune_demod_0, '0', rational_resampler_xxx_0, '0']
- [ssb_tune_demod_0_0, '0', rational_resampler_xxx_0_0, '0']
- [ssb_tune_demod_0_0_0, '0', rational_resampler_xxx_0_1, '0']
- [ssb_tune_demod_0_0_0_0, '0', rational_resampler_xxx_0_2, '0']
- [ssb_tune_demod_0_0_0_0_0, '0', rational_resampler_xxx_0_3, '0']

metadata:
  file_format: 1
