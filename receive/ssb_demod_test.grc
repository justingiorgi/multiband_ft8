options:
  parameters:
    author: Justin Giorgi AI6YM
    copyright: '2024'
    generate_options: qt_gui
    id: ssb_demod_test
    output_language: python
    title: SSB Demod Test
  states: {}

blocks:
- name: audio_samp_rate
  id: variable
  parameters:
    value: '16000'
  states: {}
- name: input_center_freq
  id: variable
  parameters:
    value: '50247000'
  states: {}
- name: input_samp_rate
  id: variable
  parameters:
    value: '256000'
  states: {}
- name: ssb_samp_rate
  id: variable
  parameters:
    value: '8000'
  states: {}
- name: tuning_freq
  id: variable
  parameters:
    value: '50300000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: default
    samp_rate: audio_samp_rate
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/justin/Downloads/ssb_lsb_256k_complex2.dat
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.000025'
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: audio_samp_rate
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    gui_hint: 3,0,1,1
    name: '"Audio"'
    type: float
    update_time: '0.001'
  states: {}
- name: qtgui_waterfall_sink_x_2
  id: qtgui_waterfall_sink_x
  parameters:
    bw: input_samp_rate
    fc: input_center_freq
    fftsize: '1024'
    gui_hint: 0,0,1,1
    name: '"Raw"'
    type: complex
    update_time: '0.001'
  states: {}
- name: qtgui_waterfall_sink_x_3
  id: qtgui_waterfall_sink_x
  parameters:
    bw: '8000'
    fc: tuning_freq-1500
    fftsize: '1024'
    gui_hint: 2,0,1,1
    name: '"SSB Tune"'
    type: complex
    update_time: '0.001'
  states: {}
- name: qtgui_waterfall_sink_x_4
  id: qtgui_waterfall_sink_x
  parameters:
    bw: '240000'
    fc: input_center_freq
    fftsize: '1024'
    gui_hint: 1,0,1,1
    name: '"Resampled"'
    type: complex
    update_time: '0.001'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: int(audio_samp_rate / ssb_samp_rate)
    type: fff
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '16'
    interp: '15'
    type: ccc
  states: {}
- name: ssb_tune_demod_0
  id: ssb_tune_demod
  parameters:
    audio_bw: '3000'
    input_center_freq: input_center_freq
    input_samp_rate: '240000'
    tuning_freq: tuning_freq
    usb_lsb: '-1'
  states: {}

connections:
- [blocks_file_source_0, '0', qtgui_waterfall_sink_x_2, '0']
- [blocks_file_source_0, '0', rational_resampler_xxx_1, '0']
- [blocks_multiply_const_vxx_1, '0', audio_sink_0, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_const_vxx_1, '0']
- [rational_resampler_xxx_0, '0', qtgui_waterfall_sink_x_1, '0']
- [rational_resampler_xxx_1, '0', qtgui_waterfall_sink_x_4, '0']
- [rational_resampler_xxx_1, '0', ssb_tune_demod_0, '0']
- [ssb_tune_demod_0, '0', rational_resampler_xxx_0, '0']
- [ssb_tune_demod_0, '1', qtgui_waterfall_sink_x_3, '0']

metadata:
  file_format: 1
